Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton 200 (10)
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes
Name | In | Classification
A-Wand034 | Erdgeschoss | Wand (Archicad Klassifizierung)
5 x Wand-026 | Staffelgeschoss | Rohbaudecke (Archicad Klassifizierung)
Decke010 | Staffelgeschoss | Rohbaudecke (Archicad Klassifizierung)
Decke020 | Staffelgeschoss | Rohbaudecke (Archicad Klassifizierung)
Decke-004 | Staffelgeschoss | Rohbaudecke (Archicad Klassifizierung)
Decke030 | Dachaufsicht | Rohbaudecke (Archicad Klassifizierung)

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton 240 (2)
In: Erdgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes
Name
A-Wand052
A-Wand053

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton 240 x 930, Unterzug-014
In: Erdgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton 250 (3)
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes
Name | In
Decke004 | Erdgeschoss
Decke009 | Staffelgeschoss
Decke-004 | Staffelgeschoss

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton 300, Decke027
In: Kellergeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton 340, Decke006
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton 400 x 2200, Stütze-003
In: Erdgeschoss
Classification: Stütze (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton 400 x 400 (11)
In: Erdgeschoss
Classification: Stütze (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton 600 x 700 (6)
In: Gründung
Classification: Fundament (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton 85 (4)
In: Staffelgeschoss
Classification: Lichtkuppel (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes
Name
A-Wand064
A-Wand061
A-Wand062
A-Wand063

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton Fertigteil 70, Decke025
In: Kellergeschoss
Classification: Elementwand (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton Fertigteil
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton Fertigteil, ThermalConductivity: 1.15; _SIWH - Beton, Stahlbeton Fertigteil, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton Fertigteil, MassDensity: 1800 kg/m3; _SIWH - Beton, Stahlbeton Fertigteil, Embodied Energy: 0.74 (MJ/kg); _SIWH - Beton, Stahlbeton Fertigteil, Embodied Carbon: 0.107 (kgCO₂/kg); _SIWH - Beton, Stahlbeton Fertigteil, Name: _SIWH - Beton, Stahlbeton Fertigteil; _SIWH - Beton, Stahlbeton Fertigteil, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Beton, Stahlbeton Polygon, Wand-026
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: _SIWH - Dämmung, hart Mineralwolle 100 (3)
In: Staffelgeschoss
Classification: Dämmung (Archicad Klassifizierung); Material: _SIWH - Dämmung, hart Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Dämmung, hart Mineralwolle, ThermalConductivity: 0.036; _SIWH - Dämmung, hart Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, hart Mineralwolle, MassDensity: 115 kg/m3; _SIWH - Dämmung, hart Mineralwolle, Embodied Energy: 21.4 (MJ/kg); _SIWH - Dämmung, hart Mineralwolle, Embodied Carbon: 1.69 (kgCO₂/kg); _SIWH - Dämmung, hart Mineralwolle, Name: _SIWH - Dämmung, hart Mineralwolle; _SIWH - Dämmung, hart Mineralwolle, Participates in Collision Detection: yes
Name
Decke012
Decke011
Decke022

# IfcBuildingElementProxy: _SIWH - Dämmung, hart Mineralwolle 140 (2)
Classification: Dämmung (Archicad Klassifizierung); Material: _SIWH - Dämmung, hart Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Dämmung, hart Mineralwolle, ThermalConductivity: 0.036; _SIWH - Dämmung, hart Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, hart Mineralwolle, MassDensity: 115 kg/m3; _SIWH - Dämmung, hart Mineralwolle, Embodied Energy: 21.4 (MJ/kg); _SIWH - Dämmung, hart Mineralwolle, Embodied Carbon: 1.69 (kgCO₂/kg); _SIWH - Dämmung, hart Mineralwolle, Name: _SIWH - Dämmung, hart Mineralwolle; _SIWH - Dämmung, hart Mineralwolle, Participates in Collision Detection: yes
Name | In
Decke014 | Staffelgeschoss
Decke032 | Dachaufsicht

# IfcBuildingElementProxy: _SIWH - Dämmung, hart Mineralwolle 150, Decke023
In: Staffelgeschoss
Classification: Dämmung (Archicad Klassifizierung); Material: _SIWH - Dämmung, hart Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Dämmung, hart Mineralwolle, ThermalConductivity: 0.036; _SIWH - Dämmung, hart Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, hart Mineralwolle, MassDensity: 115 kg/m3; _SIWH - Dämmung, hart Mineralwolle, Embodied Energy: 21.4 (MJ/kg); _SIWH - Dämmung, hart Mineralwolle, Embodied Carbon: 1.69 (kgCO₂/kg); _SIWH - Dämmung, hart Mineralwolle, Name: _SIWH - Dämmung, hart Mineralwolle; _SIWH - Dämmung, hart Mineralwolle, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Dämmung, hart Mineralwolle 275 (2)
In: Staffelgeschoss
Classification: Dämmung (Archicad Klassifizierung); Material: _SIWH - Dämmung, hart Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Dämmung, hart Mineralwolle, ThermalConductivity: 0.036; _SIWH - Dämmung, hart Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, hart Mineralwolle, MassDensity: 115 kg/m3; _SIWH - Dämmung, hart Mineralwolle, Embodied Energy: 21.4 (MJ/kg); _SIWH - Dämmung, hart Mineralwolle, Embodied Carbon: 1.69 (kgCO₂/kg); _SIWH - Dämmung, hart Mineralwolle, Name: _SIWH - Dämmung, hart Mineralwolle; _SIWH - Dämmung, hart Mineralwolle, Participates in Collision Detection: yes
Name
Decke018
Decke019

# IfcBuildingElementProxy: _SIWH - Dämmung, hart Mineralwolle 60 (2)
Classification: Dämmung (Archicad Klassifizierung); Material: _SIWH - Dämmung, hart Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Dämmung, hart Mineralwolle, ThermalConductivity: 0.036; _SIWH - Dämmung, hart Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, hart Mineralwolle, MassDensity: 115 kg/m3; _SIWH - Dämmung, hart Mineralwolle, Embodied Energy: 21.4 (MJ/kg); _SIWH - Dämmung, hart Mineralwolle, Embodied Carbon: 1.69 (kgCO₂/kg); _SIWH - Dämmung, hart Mineralwolle, Name: _SIWH - Dämmung, hart Mineralwolle; _SIWH - Dämmung, hart Mineralwolle, Participates in Collision Detection: yes
Name | In
A-Wand035 | Erdgeschoss
Decke017 | Staffelgeschoss

# IfcBuildingElementProxy: _SIWH - Dämmung, hart Mineralwolle 70 (3)
In: Kellergeschoss
Classification: Elementwand (Archicad Klassifizierung); Material: _SIWH - Dämmung, hart Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Dämmung, hart Mineralwolle, ThermalConductivity: 0.036; _SIWH - Dämmung, hart Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, hart Mineralwolle, MassDensity: 115 kg/m3; _SIWH - Dämmung, hart Mineralwolle, Embodied Energy: 21.4 (MJ/kg); _SIWH - Dämmung, hart Mineralwolle, Embodied Carbon: 1.69 (kgCO₂/kg); _SIWH - Dämmung, hart Mineralwolle, Name: _SIWH - Dämmung, hart Mineralwolle; _SIWH - Dämmung, hart Mineralwolle, Participates in Collision Detection: yes
Name
A-Wand067
Decke024
A-Wand068

# IfcBuildingElementProxy: _SIWH - Dämmung, weich Mineralwolle 180 (2)
In: Staffelgeschoss
Material: _SIWH - Dämmung, weich Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes
Name | Classification
A-Wand060 | Dämmung (Archicad Klassifizierung)
A-Wand066 | Wand (Archicad Klassifizierung)

# IfcBuildingElementProxy: _SIWH - Dämmung, weich Mineralwolle 200, Decke021
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Dämmung, weich Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Dämmung, weich Mineralwolle, hohe Priorität 180, A-Wand065
In: Staffelgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Dämmung, weich Mineralwolle, hohe Priorität
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Dämmung, weich Mineralwolle, hohe Priorität, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, hohe Priorität, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, hohe Priorität, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, hohe Priorität, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, hohe Priorität, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, hohe Priorität, Name: _SIWH - Dämmung, weich Mineralwolle, hohe Priorität; _SIWH - Dämmung, weich Mineralwolle, hohe Priorität, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Glas, Normalglas 30 (2)
In: Staffelgeschoss
Classification: Trennwand (Archicad Klassifizierung); Material: _SIWH - Glas, Normalglas
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Glas, Normalglas, ThermalConductivity: 1.4; _SIWH - Glas, Normalglas, SpecificHeatCapacity: 750 J/kg/K; _SIWH - Glas, Normalglas, MassDensity: 2200 kg/m3; _SIWH - Glas, Normalglas, Embodied Energy: 0.85 (MJ/kg); _SIWH - Glas, Normalglas, Embodied Carbon: 0.02 (kgCO₂/kg); _SIWH - Glas, Normalglas, Name: _SIWH - Glas, Normalglas; _SIWH - Glas, Normalglas, Participates in Collision Detection: yes
Name
L-Wand047
L-Wand046

# IfcBuildingElementProxy: _SIWH - Gründach (5)
Material: _SIWH - Gründach
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Gründach, ThermalConductivity: 0.8; _SIWH - Gründach, SpecificHeatCapacity: 800 J/kg/K; _SIWH - Gründach, MassDensity: 2300 kg/m3; _SIWH - Gründach, Embodied Energy: 0.92 (MJ/kg); _SIWH - Gründach, Embodied Carbon: 0.15 (kgCO₂/kg); _SIWH - Gründach, Name: _SIWH - Gründach; _SIWH - Gründach, Participates in Collision Detection: yes
Name | In | Classification
2 x Freifläche-006 | Staffelgeschoss | Dachdeckung (Archicad Klassifizierung)
2 x Freifläche-006 | Staffelgeschoss | Dämmung (Archicad Klassifizierung)
Freifläche-004 | Dachaufsicht | Dachdeckung (Archicad Klassifizierung)

# IfcBuildingElementProxy: _SIWH - Lichtschacht 1270x800 870 x 1410, Stütze-004
In: Kellergeschoss
Classification: Schacht / Graben / Revisionsschacht (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton Fertigteil, _SIWH - Dämmung, hart Mineralwolle (2)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton Fertigteil, ThermalConductivity: 1.15; _SIWH - Beton, Stahlbeton Fertigteil, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton Fertigteil, MassDensity: 1800 kg/m3; _SIWH - Beton, Stahlbeton Fertigteil, Embodied Energy: 0.74 (MJ/kg); _SIWH - Beton, Stahlbeton Fertigteil, Embodied Carbon: 0.107 (kgCO₂/kg); _SIWH - Beton, Stahlbeton Fertigteil, Name: _SIWH - Beton, Stahlbeton Fertigteil; _SIWH - Beton, Stahlbeton Fertigteil, Participates in Collision Detection: yes; _SIWH - Dämmung, hart Mineralwolle, ThermalConductivity: 0.036; _SIWH - Dämmung, hart Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, hart Mineralwolle, MassDensity: 115 kg/m3; _SIWH - Dämmung, hart Mineralwolle, Embodied Energy: 21.4 (MJ/kg); _SIWH - Dämmung, hart Mineralwolle, Embodied Carbon: 1.69 (kgCO₂/kg); _SIWH - Dämmung, hart Mineralwolle, Name: _SIWH - Dämmung, hart Mineralwolle; _SIWH - Dämmung, hart Mineralwolle, Participates in Collision Detection: yes; _SIWH - Dämmung, hart Mineralwolle: 2 with these values

# IfcBuildingElementProxy: _SIWH - MW Kalksandstein, nichttragend 120, L-Wand045
In: Staffelgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - MW Kalksandstein, nichttragend
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - MW Kalksandstein, nichttragend, ThermalConductivity: 0.93; _SIWH - MW Kalksandstein, nichttragend, SpecificHeatCapacity: 840 J/kg/K; _SIWH - MW Kalksandstein, nichttragend, MassDensity: 1800 kg/m3; _SIWH - MW Kalksandstein, nichttragend, Embodied Energy: 1.2 (MJ/kg); _SIWH - MW Kalksandstein, nichttragend, Embodied Carbon: 0.07 (kgCO₂/kg); _SIWH - MW Kalksandstein, nichttragend, Name: _SIWH - MW Kalksandstein, nichttragend; _SIWH - MW Kalksandstein, nichttragend, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Schotter, fein, Freifläche-004
In: Dachaufsicht
Classification: Dachdeckung (Archicad Klassifizierung); Material: _SIWH - Schotter, fein
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Schotter, fein, ThermalConductivity: 0.55; _SIWH - Schotter, fein, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Schotter, fein, MassDensity: 1600 kg/m3; _SIWH - Schotter, fein, Embodied Energy: 1 (MJ/kg); _SIWH - Schotter, fein, Embodied Carbon: 0.06 (kgCO₂/kg); _SIWH - Schotter, fein, Name: _SIWH - Schotter, fein; _SIWH - Schotter, fein, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Schotter, fein 150, Decke053
In: Staffelgeschoss
Classification: Dachdeckung (Archicad Klassifizierung); Material: _SIWH - Schotter, fein
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Schotter, fein, ThermalConductivity: 0.55; _SIWH - Schotter, fein, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Schotter, fein, MassDensity: 1600 kg/m3; _SIWH - Schotter, fein, Embodied Energy: 1 (MJ/kg); _SIWH - Schotter, fein, Embodied Carbon: 0.06 (kgCO₂/kg); _SIWH - Schotter, fein, Name: _SIWH - Schotter, fein; _SIWH - Schotter, fein, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Schotter, fein 200, Decke054
In: Staffelgeschoss
Classification: Dachdeckung (Archicad Klassifizierung); Material: _SIWH - Schotter, fein
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Schotter, fein, ThermalConductivity: 0.55; _SIWH - Schotter, fein, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Schotter, fein, MassDensity: 1600 kg/m3; _SIWH - Schotter, fein, Embodied Energy: 1 (MJ/kg); _SIWH - Schotter, fein, Embodied Carbon: 0.06 (kgCO₂/kg); _SIWH - Schotter, fein, Name: _SIWH - Schotter, fein; _SIWH - Schotter, fein, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Sturz Außenwand EG - Stb. 20cm 515 x 280, A-Wand020
In: Erdgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - MW Vormauerziegel, _SIWH - Luftschicht vertikal, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - MW Vormauerziegel, ThermalConductivity: 0.109; _SIWH - MW Vormauerziegel, SpecificHeatCapacity: 920 J/kg/K; _SIWH - MW Vormauerziegel, MassDensity: 600 kg/m3; _SIWH - MW Vormauerziegel, Embodied Energy: 6 (MJ/kg); _SIWH - MW Vormauerziegel, Embodied Carbon: 0.48 (kgCO₂/kg); _SIWH - MW Vormauerziegel, Name: _SIWH - MW Vormauerziegel; _SIWH - MW Vormauerziegel, Participates in Collision Detection: yes; _SIWH - Luftschicht vertikal, ThermalConductivity: 0.16; _SIWH - Luftschicht vertikal, SpecificHeatCapacity: 1008 J/kg/K; _SIWH - Luftschicht vertikal, MassDensity: 1.2 kg/m3; _SIWH - Luftschicht vertikal, Embodied Energy: 0 (MJ/kg); _SIWH - Luftschicht vertikal, Embodied Carbon: 0 (kgCO₂/kg); _SIWH - Luftschicht vertikal, Name: _SIWH - Luftschicht vertikal; _SIWH - Luftschicht vertikal, Participates in Collision Detection: no; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Sturz Außenwand EG 555 x 330 (5)
In: Erdgeschoss
Classification: Wand (Archicad Klassifizierung)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Luftschicht vertikal, ThermalConductivity: 0.16; _SIWH - Luftschicht vertikal, SpecificHeatCapacity: 1008 J/kg/K; _SIWH - Luftschicht vertikal, MassDensity: 1.2 kg/m3; _SIWH - Luftschicht vertikal, Embodied Energy: 0 (MJ/kg); _SIWH - Luftschicht vertikal, Embodied Carbon: 0 (kgCO₂/kg); _SIWH - Luftschicht vertikal, Name: _SIWH - Luftschicht vertikal; _SIWH - Luftschicht vertikal, Participates in Collision Detection: no; _SIWH - MW Vormauerziegel, ThermalConductivity: 0.109; _SIWH - MW Vormauerziegel, SpecificHeatCapacity: 920 J/kg/K; _SIWH - MW Vormauerziegel, MassDensity: 600 kg/m3; _SIWH - MW Vormauerziegel, Embodied Energy: 6 (MJ/kg); _SIWH - MW Vormauerziegel, Embodied Carbon: 0.48 (kgCO₂/kg); _SIWH - MW Vormauerziegel, Name: _SIWH - MW Vormauerziegel; _SIWH - MW Vormauerziegel, Participates in Collision Detection: yes
Name | Material
A-Wand010 | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel
A-Wand009 | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel
A-Wand016 | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel
A-Wand041 | _SIWH - MW Vormauerziegel, _SIWH - Luftschicht vertikal, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Beton, Stahlbeton
A-Wand013 | _SIWH - MW Vormauerziegel, _SIWH - Luftschicht vertikal, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Beton, Stahlbeton

# IfcBuildingElementProxy: _SIWH - Sturz Außenwand EG Garage 615 x 280 (2)
In: Erdgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - MW Vormauerziegel, _SIWH - Luftschicht vertikal, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - MW Vormauerziegel, ThermalConductivity: 0.109; _SIWH - MW Vormauerziegel, SpecificHeatCapacity: 920 J/kg/K; _SIWH - MW Vormauerziegel, MassDensity: 600 kg/m3; _SIWH - MW Vormauerziegel, Embodied Energy: 6 (MJ/kg); _SIWH - MW Vormauerziegel, Embodied Carbon: 0.48 (kgCO₂/kg); _SIWH - MW Vormauerziegel, Name: _SIWH - MW Vormauerziegel; _SIWH - MW Vormauerziegel, Participates in Collision Detection: yes; _SIWH - Luftschicht vertikal, ThermalConductivity: 0.16; _SIWH - Luftschicht vertikal, SpecificHeatCapacity: 1008 J/kg/K; _SIWH - Luftschicht vertikal, MassDensity: 1.2 kg/m3; _SIWH - Luftschicht vertikal, Embodied Energy: 0 (MJ/kg); _SIWH - Luftschicht vertikal, Embodied Carbon: 0 (kgCO₂/kg); _SIWH - Luftschicht vertikal, Name: _SIWH - Luftschicht vertikal; _SIWH - Luftschicht vertikal, Participates in Collision Detection: no; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes
Name
A-Wand019
A-Wand018

# IfcBuildingElementProxy: _SIWH - Sturz Außenwand EG Vordach 555 x 280 (2)
In: Erdgeschoss
Classification: Wand (Archicad Klassifizierung)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Luftschicht vertikal, ThermalConductivity: 0.16; _SIWH - Luftschicht vertikal, SpecificHeatCapacity: 1008 J/kg/K; _SIWH - Luftschicht vertikal, MassDensity: 1.2 kg/m3; _SIWH - Luftschicht vertikal, Embodied Energy: 0 (MJ/kg); _SIWH - Luftschicht vertikal, Embodied Carbon: 0 (kgCO₂/kg); _SIWH - Luftschicht vertikal, Name: _SIWH - Luftschicht vertikal; _SIWH - Luftschicht vertikal, Participates in Collision Detection: no; _SIWH - MW Vormauerziegel, ThermalConductivity: 0.109; _SIWH - MW Vormauerziegel, SpecificHeatCapacity: 920 J/kg/K; _SIWH - MW Vormauerziegel, MassDensity: 600 kg/m3; _SIWH - MW Vormauerziegel, Embodied Energy: 6 (MJ/kg); _SIWH - MW Vormauerziegel, Embodied Carbon: 0.48 (kgCO₂/kg); _SIWH - MW Vormauerziegel, Name: _SIWH - MW Vormauerziegel; _SIWH - MW Vormauerziegel, Participates in Collision Detection: yes
Name | Material
A-Wand022 | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel
A-Wand017 | _SIWH - MW Vormauerziegel, _SIWH - Luftschicht vertikal, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Beton, Stahlbeton

# IfcBuildingElementProxy: _SIWH - Terrasse Luftbalken 140 x 915 (2)
In: Staffelgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton Fertigteil
Material Properties - _SIWH - Beton, Stahlbeton Fertigteil, ThermalConductivity: 1.15; _SIWH - Beton, Stahlbeton Fertigteil, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton Fertigteil, MassDensity: 1800 kg/m3; _SIWH - Beton, Stahlbeton Fertigteil, Embodied Energy: 0.74 (MJ/kg); _SIWH - Beton, Stahlbeton Fertigteil, Embodied Carbon: 0.107 (kgCO₂/kg); _SIWH - Beton, Stahlbeton Fertigteil, Name: _SIWH - Beton, Stahlbeton Fertigteil; _SIWH - Beton, Stahlbeton Fertigteil, Participates in Collision Detection: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: _SIWH - Vordach Eingang 1 4035 x 310, Wand-024
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Holz, Bauholz (4), _SIWH - Abgehängte Decke Arkade (3), _SIWH - Luftschicht vertikal (3), _SIWH - Dämmung, weich Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Holz, Bauholz, ThermalConductivity: 0.13; _SIWH - Holz, Bauholz, SpecificHeatCapacity: 1600 J/kg/K; _SIWH - Holz, Bauholz, MassDensity: 500 kg/m3; _SIWH - Holz, Bauholz, Embodied Energy: 6.95 (MJ/kg); _SIWH - Holz, Bauholz, Embodied Carbon: 0.29 (kgCO₂/kg); _SIWH - Holz, Bauholz, Name: _SIWH - Holz, Bauholz; _SIWH - Holz, Bauholz, Participates in Collision Detection: yes; _SIWH - Abgehängte Decke Arkade, ThermalConductivity: 0.13; _SIWH - Abgehängte Decke Arkade, SpecificHeatCapacity: 1600 J/kg/K; _SIWH - Abgehängte Decke Arkade, MassDensity: 500 kg/m3; _SIWH - Abgehängte Decke Arkade, Embodied Energy: 13.1 (MJ/kg); _SIWH - Abgehängte Decke Arkade, Embodied Carbon: 0.64 (kgCO₂/kg); _SIWH - Abgehängte Decke Arkade, Name: _SIWH - Abgehängte Decke Arkade; _SIWH - Abgehängte Decke Arkade, Participates in Collision Detection: yes; _SIWH - Luftschicht vertikal, ThermalConductivity: 0.16; _SIWH - Luftschicht vertikal, SpecificHeatCapacity: 1008 J/kg/K; _SIWH - Luftschicht vertikal, MassDensity: 1.2 kg/m3; _SIWH - Luftschicht vertikal, Embodied Energy: 0 (MJ/kg); _SIWH - Luftschicht vertikal, Embodied Carbon: 0 (kgCO₂/kg); _SIWH - Luftschicht vertikal, Name: _SIWH - Luftschicht vertikal; _SIWH - Luftschicht vertikal, Participates in Collision Detection: no; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Holz, Bauholz: 4 with these values; _SIWH - Abgehängte Decke Arkade: 3 with these values; _SIWH - Luftschicht vertikal: 3 with these values

# IfcBuildingElementProxy: _SIWH - Vordach Eingang 2 2720 x 310 (2)
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Abgehängte Decke Arkade (3), _SIWH - Holz, Bauholz (2), _SIWH - Luftschicht vertikal (2), _SIWH - Dämmung, weich Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Abgehängte Decke Arkade, ThermalConductivity: 0.13; _SIWH - Abgehängte Decke Arkade, SpecificHeatCapacity: 1600 J/kg/K; _SIWH - Abgehängte Decke Arkade, MassDensity: 500 kg/m3; _SIWH - Abgehängte Decke Arkade, Embodied Energy: 13.1 (MJ/kg); _SIWH - Abgehängte Decke Arkade, Embodied Carbon: 0.64 (kgCO₂/kg); _SIWH - Abgehängte Decke Arkade, Name: _SIWH - Abgehängte Decke Arkade; _SIWH - Abgehängte Decke Arkade, Participates in Collision Detection: yes; _SIWH - Holz, Bauholz, ThermalConductivity: 0.13; _SIWH - Holz, Bauholz, SpecificHeatCapacity: 1600 J/kg/K; _SIWH - Holz, Bauholz, MassDensity: 500 kg/m3; _SIWH - Holz, Bauholz, Embodied Energy: 6.95 (MJ/kg); _SIWH - Holz, Bauholz, Embodied Carbon: 0.29 (kgCO₂/kg); _SIWH - Holz, Bauholz, Name: _SIWH - Holz, Bauholz; _SIWH - Holz, Bauholz, Participates in Collision Detection: yes; _SIWH - Luftschicht vertikal, ThermalConductivity: 0.16; _SIWH - Luftschicht vertikal, SpecificHeatCapacity: 1008 J/kg/K; _SIWH - Luftschicht vertikal, MassDensity: 1.2 kg/m3; _SIWH - Luftschicht vertikal, Embodied Energy: 0 (MJ/kg); _SIWH - Luftschicht vertikal, Embodied Carbon: 0 (kgCO₂/kg); _SIWH - Luftschicht vertikal, Name: _SIWH - Luftschicht vertikal; _SIWH - Luftschicht vertikal, Participates in Collision Detection: no; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Abgehängte Decke Arkade: 3 with these values; _SIWH - Holz, Bauholz: 2 with these values; _SIWH - Luftschicht vertikal: 2 with these values

# IfcBuildingElementProxy: _SIWH - Vordach Luftbalken2 410 x 980, Wand-024
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Metall, Aluminium, _SIWH - Beton, Stahlbeton Fertigteil
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Metall, Aluminium, ThermalConductivity: 160; _SIWH - Metall, Aluminium, SpecificHeatCapacity: 880 J/kg/K; _SIWH - Metall, Aluminium, MassDensity: 2800 kg/m3; _SIWH - Metall, Aluminium, Embodied Energy: 155 (MJ/kg); _SIWH - Metall, Aluminium, Embodied Carbon: 9.16 (kgCO₂/kg); _SIWH - Metall, Aluminium, Name: _SIWH - Metall, Aluminium; _SIWH - Metall, Aluminium, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton Fertigteil, ThermalConductivity: 1.15; _SIWH - Beton, Stahlbeton Fertigteil, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton Fertigteil, MassDensity: 1800 kg/m3; _SIWH - Beton, Stahlbeton Fertigteil, Embodied Energy: 0.74 (MJ/kg); _SIWH - Beton, Stahlbeton Fertigteil, Embodied Carbon: 0.107 (kgCO₂/kg); _SIWH - Beton, Stahlbeton Fertigteil, Name: _SIWH - Beton, Stahlbeton Fertigteil; _SIWH - Beton, Stahlbeton Fertigteil, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Vordach+Arkade1 1555 x 980 (3)
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Metall, Aluminium, _SIWH - Beton, Stahlbeton Fertigteil, _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle
Material Properties - _SIWH - Metall, Aluminium, ThermalConductivity: 160; _SIWH - Metall, Aluminium, SpecificHeatCapacity: 880 J/kg/K; _SIWH - Metall, Aluminium, MassDensity: 2800 kg/m3; _SIWH - Metall, Aluminium, Embodied Energy: 155 (MJ/kg); _SIWH - Metall, Aluminium, Embodied Carbon: 9.16 (kgCO₂/kg); _SIWH - Metall, Aluminium, Name: _SIWH - Metall, Aluminium; _SIWH - Metall, Aluminium, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton Fertigteil, ThermalConductivity: 1.15; _SIWH - Beton, Stahlbeton Fertigteil, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton Fertigteil, MassDensity: 1800 kg/m3; _SIWH - Beton, Stahlbeton Fertigteil, Embodied Energy: 0.74 (MJ/kg); _SIWH - Beton, Stahlbeton Fertigteil, Embodied Carbon: 0.107 (kgCO₂/kg); _SIWH - Beton, Stahlbeton Fertigteil, Name: _SIWH - Beton, Stahlbeton Fertigteil; _SIWH - Beton, Stahlbeton Fertigteil, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: _SIWH - Vordach+Arkade2 1555 x 980, Wand-024
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Metall, Aluminium, _SIWH - Beton, Stahlbeton Fertigteil, _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle
Material Properties - _SIWH - Metall, Aluminium, ThermalConductivity: 160; _SIWH - Metall, Aluminium, SpecificHeatCapacity: 880 J/kg/K; _SIWH - Metall, Aluminium, MassDensity: 2800 kg/m3; _SIWH - Metall, Aluminium, Embodied Energy: 155 (MJ/kg); _SIWH - Metall, Aluminium, Embodied Carbon: 9.16 (kgCO₂/kg); _SIWH - Metall, Aluminium, Name: _SIWH - Metall, Aluminium; _SIWH - Metall, Aluminium, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton Fertigteil, ThermalConductivity: 1.15; _SIWH - Beton, Stahlbeton Fertigteil, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton Fertigteil, MassDensity: 1800 kg/m3; _SIWH - Beton, Stahlbeton Fertigteil, Embodied Energy: 0.74 (MJ/kg); _SIWH - Beton, Stahlbeton Fertigteil, Embodied Carbon: 0.107 (kgCO₂/kg); _SIWH - Beton, Stahlbeton Fertigteil, Name: _SIWH - Beton, Stahlbeton Fertigteil; _SIWH - Beton, Stahlbeton Fertigteil, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: _SIWH - Vordach+Arkade2 nur Luftbalken 210 x 650, Wand-024
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Metall, Aluminium, _SIWH - Beton, Stahlbeton Fertigteil
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Metall, Aluminium, ThermalConductivity: 160; _SIWH - Metall, Aluminium, SpecificHeatCapacity: 880 J/kg/K; _SIWH - Metall, Aluminium, MassDensity: 2800 kg/m3; _SIWH - Metall, Aluminium, Embodied Energy: 155 (MJ/kg); _SIWH - Metall, Aluminium, Embodied Carbon: 9.16 (kgCO₂/kg); _SIWH - Metall, Aluminium, Name: _SIWH - Metall, Aluminium; _SIWH - Metall, Aluminium, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton Fertigteil, ThermalConductivity: 1.15; _SIWH - Beton, Stahlbeton Fertigteil, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton Fertigteil, MassDensity: 1800 kg/m3; _SIWH - Beton, Stahlbeton Fertigteil, Embodied Energy: 0.74 (MJ/kg); _SIWH - Beton, Stahlbeton Fertigteil, Embodied Carbon: 0.107 (kgCO₂/kg); _SIWH - Beton, Stahlbeton Fertigteil, Name: _SIWH - Beton, Stahlbeton Fertigteil; _SIWH - Beton, Stahlbeton Fertigteil, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Vordach+Arkade3 1395 x 980, Wand-024
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Metall, Aluminium, _SIWH - Beton, Stahlbeton Fertigteil, _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Metall, Aluminium, ThermalConductivity: 160; _SIWH - Metall, Aluminium, SpecificHeatCapacity: 880 J/kg/K; _SIWH - Metall, Aluminium, MassDensity: 2800 kg/m3; _SIWH - Metall, Aluminium, Embodied Energy: 155 (MJ/kg); _SIWH - Metall, Aluminium, Embodied Carbon: 9.16 (kgCO₂/kg); _SIWH - Metall, Aluminium, Name: _SIWH - Metall, Aluminium; _SIWH - Metall, Aluminium, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton Fertigteil, ThermalConductivity: 1.15; _SIWH - Beton, Stahlbeton Fertigteil, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton Fertigteil, MassDensity: 1800 kg/m3; _SIWH - Beton, Stahlbeton Fertigteil, Embodied Energy: 0.74 (MJ/kg); _SIWH - Beton, Stahlbeton Fertigteil, Embodied Carbon: 0.107 (kgCO₂/kg); _SIWH - Beton, Stahlbeton Fertigteil, Name: _SIWH - Beton, Stahlbeton Fertigteil; _SIWH - Beton, Stahlbeton Fertigteil, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - Vordach+Arkade3 nur Luftbalken 210 x 980 (2)
In: Staffelgeschoss
Classification: Rohbaudecke (Archicad Klassifizierung); Material: _SIWH - Metall, Aluminium, _SIWH - Beton, Stahlbeton Fertigteil
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Metall, Aluminium, ThermalConductivity: 160; _SIWH - Metall, Aluminium, SpecificHeatCapacity: 880 J/kg/K; _SIWH - Metall, Aluminium, MassDensity: 2800 kg/m3; _SIWH - Metall, Aluminium, Embodied Energy: 155 (MJ/kg); _SIWH - Metall, Aluminium, Embodied Carbon: 9.16 (kgCO₂/kg); _SIWH - Metall, Aluminium, Name: _SIWH - Metall, Aluminium; _SIWH - Metall, Aluminium, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton Fertigteil, ThermalConductivity: 1.15; _SIWH - Beton, Stahlbeton Fertigteil, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton Fertigteil, MassDensity: 1800 kg/m3; _SIWH - Beton, Stahlbeton Fertigteil, Embodied Energy: 0.74 (MJ/kg); _SIWH - Beton, Stahlbeton Fertigteil, Embodied Carbon: 0.107 (kgCO₂/kg); _SIWH - Beton, Stahlbeton Fertigteil, Name: _SIWH - Beton, Stahlbeton Fertigteil; _SIWH - Beton, Stahlbeton Fertigteil, Participates in Collision Detection: yes

# IfcBuildingElementProxy: _SIWH - WA | Perimeterdämmung 8 | 8cm 80, A-Wand029
In: Kellergeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Dämmung, Perimeterdämmung
Material Properties - _SIWH - Dämmung, Perimeterdämmung, ThermalConductivity: 0.046; _SIWH - Dämmung, Perimeterdämmung, SpecificHeatCapacity: 900 J/kg/K; _SIWH - Dämmung, Perimeterdämmung, MassDensity: 151.33 kg/m3; _SIWH - Dämmung, Perimeterdämmung, Embodied Energy: 13.5 (MJ/kg); _SIWH - Dämmung, Perimeterdämmung, Embodied Carbon: 0.9 (kgCO₂/kg); _SIWH - Dämmung, Perimeterdämmung, Name: _SIWH - Dämmung, Perimeterdämmung; _SIWH - Dämmung, Perimeterdämmung, Participates in Collision Detection: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: _SIWH - WA | Stb. 20+WD 18 | 38cm 380 (6)
Classification: Wand (Archicad Klassifizierung)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes
Name | In | Material
A-Wand021 | Erdgeschoss | _SIWH - Dämmung, weich Mineralwolle, _SIWH - Beton, Stahlbeton
A-Wand051 | Staffelgeschoss | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle
A-Wand050 | Staffelgeschoss | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle
A-Wand049 | Staffelgeschoss | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle
A-Wand048 | Staffelgeschoss | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle
A-Wand047 | Staffelgeschoss | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle

# IfcBuildingElementProxy: _SIWH - WA | Stb. 20+WD 18+LS 2+Verblender 11,5 | 51,5cm 515 (6)
Classification: Wand (Archicad Klassifizierung)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Luftschicht vertikal, ThermalConductivity: 0.16; _SIWH - Luftschicht vertikal, SpecificHeatCapacity: 1008 J/kg/K; _SIWH - Luftschicht vertikal, MassDensity: 1.2 kg/m3; _SIWH - Luftschicht vertikal, Embodied Energy: 0 (MJ/kg); _SIWH - Luftschicht vertikal, Embodied Carbon: 0 (kgCO₂/kg); _SIWH - Luftschicht vertikal, Name: _SIWH - Luftschicht vertikal; _SIWH - Luftschicht vertikal, Participates in Collision Detection: no; _SIWH - MW Vormauerziegel, ThermalConductivity: 0.109; _SIWH - MW Vormauerziegel, SpecificHeatCapacity: 920 J/kg/K; _SIWH - MW Vormauerziegel, MassDensity: 600 kg/m3; _SIWH - MW Vormauerziegel, Embodied Energy: 6 (MJ/kg); _SIWH - MW Vormauerziegel, Embodied Carbon: 0.48 (kgCO₂/kg); _SIWH - MW Vormauerziegel, Name: _SIWH - MW Vormauerziegel; _SIWH - MW Vormauerziegel, Participates in Collision Detection: yes
Name | In | Material
A-Wand001 | Erdgeschoss | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel
A-Wand003 | Erdgeschoss | _SIWH - MW Vormauerziegel, _SIWH - Luftschicht vertikal, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Beton, Stahlbeton
A-Wand043 | Staffelgeschoss | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel
A-Wand044 | Staffelgeschoss | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel
A-Wand045 | Staffelgeschoss | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel
A-Wand046 | Staffelgeschoss | _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel

# IfcBuildingElementProxy: _SIWH - WA | Stb. 24+WD 18 | 42cm 420 (6)
In: Erdgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes
Name
A-Wand011
A-Wand008
A-Wand007
A-Wand014
A-Wand015
A-Wand012

# IfcBuildingElementProxy: _SIWH - WA | Stb. 24+WD 18+LS 2+Verblender 11,5 | 55,5cm 555 (6)
In: Erdgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Luftschicht vertikal, ThermalConductivity: 0.16; _SIWH - Luftschicht vertikal, SpecificHeatCapacity: 1008 J/kg/K; _SIWH - Luftschicht vertikal, MassDensity: 1.2 kg/m3; _SIWH - Luftschicht vertikal, Embodied Energy: 0 (MJ/kg); _SIWH - Luftschicht vertikal, Embodied Carbon: 0 (kgCO₂/kg); _SIWH - Luftschicht vertikal, Name: _SIWH - Luftschicht vertikal; _SIWH - Luftschicht vertikal, Participates in Collision Detection: no; _SIWH - MW Vormauerziegel, ThermalConductivity: 0.109; _SIWH - MW Vormauerziegel, SpecificHeatCapacity: 920 J/kg/K; _SIWH - MW Vormauerziegel, MassDensity: 600 kg/m3; _SIWH - MW Vormauerziegel, Embodied Energy: 6 (MJ/kg); _SIWH - MW Vormauerziegel, Embodied Carbon: 0.48 (kgCO₂/kg); _SIWH - MW Vormauerziegel, Name: _SIWH - MW Vormauerziegel; _SIWH - MW Vormauerziegel, Participates in Collision Detection: yes
Name
A-Wand042
A-Wand026
A-Wand027
A-Wand040
A-Wand004
A-Wand028

# IfcBuildingElementProxy: _SIWH - WA | Stb. 30 | 30cm 300 (5)
In: Kellergeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes
Name
A-Wand000
A-Wand039
A-Wand002
A-Wand025
A-Wand024

# IfcBuildingElementProxy: _SIWH - WA | Stb. 30+WD 18+LS 2+Verblender 11,5 | 61,5 615 (2)
In: Erdgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Beton, Stahlbeton, _SIWH - Dämmung, weich Mineralwolle, _SIWH - Luftschicht vertikal, _SIWH - MW Vormauerziegel
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Beton, Stahlbeton, ThermalConductivity: 1.35; _SIWH - Beton, Stahlbeton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Beton, Stahlbeton, MassDensity: 2000 kg/m3; _SIWH - Beton, Stahlbeton, Embodied Energy: 0.78 (MJ/kg); _SIWH - Beton, Stahlbeton, Embodied Carbon: 0.113 (kgCO₂/kg); _SIWH - Beton, Stahlbeton, Name: _SIWH - Beton, Stahlbeton; _SIWH - Beton, Stahlbeton, Participates in Collision Detection: yes; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Luftschicht vertikal, ThermalConductivity: 0.16; _SIWH - Luftschicht vertikal, SpecificHeatCapacity: 1008 J/kg/K; _SIWH - Luftschicht vertikal, MassDensity: 1.2 kg/m3; _SIWH - Luftschicht vertikal, Embodied Energy: 0 (MJ/kg); _SIWH - Luftschicht vertikal, Embodied Carbon: 0 (kgCO₂/kg); _SIWH - Luftschicht vertikal, Name: _SIWH - Luftschicht vertikal; _SIWH - Luftschicht vertikal, Participates in Collision Detection: no; _SIWH - MW Vormauerziegel, ThermalConductivity: 0.109; _SIWH - MW Vormauerziegel, SpecificHeatCapacity: 920 J/kg/K; _SIWH - MW Vormauerziegel, MassDensity: 600 kg/m3; _SIWH - MW Vormauerziegel, Embodied Energy: 6 (MJ/kg); _SIWH - MW Vormauerziegel, Embodied Carbon: 0.48 (kgCO₂/kg); _SIWH - MW Vormauerziegel, Name: _SIWH - MW Vormauerziegel; _SIWH - MW Vormauerziegel, Participates in Collision Detection: yes
Name
A-Wand005
A-Wand023

# IfcBuildingElementProxy: _SIWH - WI | GK 2-lagig | 12,5cm 125 (5)
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Gipskarton (4), _SIWH - Dämmung, weich Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Material Properties - _SIWH - Gipskarton, ThermalConductivity: 0.25; _SIWH - Gipskarton, SpecificHeatCapacity: 1000 J/kg/K; _SIWH - Gipskarton, MassDensity: 900 kg/m3; _SIWH - Gipskarton, Embodied Energy: 6.75 (MJ/kg); _SIWH - Gipskarton, Embodied Carbon: 0.39 (kgCO₂/kg); _SIWH - Gipskarton, Name: _SIWH - Gipskarton; _SIWH - Gipskarton, Participates in Collision Detection: yes; _SIWH - Dämmung, weich Mineralwolle, ThermalConductivity: 0.037; _SIWH - Dämmung, weich Mineralwolle, SpecificHeatCapacity: 840 J/kg/K; _SIWH - Dämmung, weich Mineralwolle, MassDensity: 40 kg/m3; _SIWH - Dämmung, weich Mineralwolle, Embodied Energy: 14.3 (MJ/kg); _SIWH - Dämmung, weich Mineralwolle, Embodied Carbon: 1.08 (kgCO₂/kg); _SIWH - Dämmung, weich Mineralwolle, Name: _SIWH - Dämmung, weich Mineralwolle; _SIWH - Dämmung, weich Mineralwolle, Participates in Collision Detection: yes; _SIWH - Gipskarton: 4 with these values
Name | In
L-Wand025 | Erdgeschoss
L-Wand026 | Erdgeschoss
L-Wand044 | Erdgeschoss
L-Wand039 | Staffelgeschoss
L-Wand040 | Staffelgeschoss

# IfcBuildingElementProxy: _SIWH - WI | GK 2-lagig | 15cm 150, L-Wand043
In: Erdgeschoss
Classification: Wand (Archicad Klassifizierung); Material: _SIWH - Gipskarton (4), _SIWH - Dämmung, weich Mineralwolle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
